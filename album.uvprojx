# Keil uVision project album.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: album
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\lib\headers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c album.c camera.c
    ./lib/: delay.c exti.c key.c lcd.c led.c ov7670.c remote.c sccb.c sys.c timer.c usart.c usmart.c usmart_config.c usmart_str.c 24cxx.c bmp.c ctiic.c diskio.c exfuns.c fattester.c ff.c gif.c gt9147.c malloc.c mmc_sd.c myiic.c ott2001a.c piclib.c spi.c stmflash.c tjpgd.c touch.c unicode.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
